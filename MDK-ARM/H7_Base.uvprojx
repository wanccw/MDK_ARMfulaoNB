# Keil uVision project H7_Base.uvprojx, settings and files
target H7_Base (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: H7_Base +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H750xx
  c include: ../Inc;  ../Drivers/STM32H7xx_HAL_Driver/Inc;  ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Device/ST/STM32H7xx/Include;  ../Drivers/CMSIS/Include;  ../CubotMiddleware;  ../new;  ../User;  ../CubotMiddleware/Algorithms;  ../CubotMiddleware/Devices;  ../CubotMiddleware/Drivers;  ../CubotMiddleware/Modules;  ../CubotMiddleware/Support;  ./H7_Base;  ../CubotMiddleware/Devices/BMI088;  ../CubotMiddleware/Devices/MPU6050;  ..\CubotMiddleware\Devices\DMP_MPU6050\delay;  ..\CubotMiddleware\Devices\DMP_MPU6050\eMPL;  ..\CubotMiddleware\Devices\DMP_MPU6050\IIC;  ..\CubotMiddleware\Devices\DMP_MPU6050\sys;  ..\CubotMiddleware\Devices\DMP_MPU6050
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User
    ../Src/: main.c gpio.c dma.c fdcan.c i2c.c iwdg.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Cubot/driver
    ../CubotMiddleware/Drivers/: driver_can.c driver_usart.c driver_iic.c driver_timer.c
  group Cubot/devices
    ./H7_Base/: referee.c
    ../CubotMiddleware/Devices/: motor.c dr16.c Supercap.c interaction.c check.c
    ../new/: heat_control.c
  group Cubot/modules
    ../new/: load.c holder.c
    ../CubotMiddleware/Modules/: mecanum_chassis.c swerve_chassis.c
    ./H7_Base/: all_chassis.c
  group User/Config
    ../User/: control_logic.c hardware_config.c
  group Cubot/Algorithm
    ../CubotMiddleware/Algorithms/: kalman.c pid.c
    ../CubotMiddleware/Devices/: filter.c
  group Cubot/BMI088
    ../CubotMiddleware/Devices/BMI088/: bmi08a.c bmi08g.c bmi088.c imu.c init_bmi088.c Prepare_data.c spi_bmi088.c
  group vision
    ../new/: brain.c
  group Cubot/MPU6050
    ../CubotMiddleware/Devices/MPU6050/: driver_iic.c Gyro.c mpu6050.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
software components: CMSIS:CORE 4.3.0
